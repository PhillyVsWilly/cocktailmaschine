# Keil uVision project Cocktailmaschine.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F303RE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Cocktailmaschine
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Include;.\Drivers\BSP\STM32F3xx-Nucleo;.\Drivers\CMSIS\Device\ST\STM32F3xx\Include;.\Drivers\STM32F3xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MainCycle
    ./Source/: Actuators.c Evaluation.c main.c Sensors.c
  group Modules
    ./Source/: Module_1_Transportation.c Module_2_Gravity.c Module_3_Pumping.c Module_4_Pouring.c Module_5_Sensors.c Module_6_Handling.c Module_7_Ice.c
  group HardwareStartup
    ./Source/: HardwareSetup.c
    ./: startup_stm32f303xe.s
  group Drivers/CMSIS
    ./Source/: system_stm32f3xx.c
  group Drivers/HAL
    ./Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c
  group Drivers/BSP
    ./Drivers/BSP/STM32F3xx-Nucleo/: stm32f3xx_nucleo.c
  group Util
    ./Source/: Debug.c
software components: RTOS:Config 9.0.0, RTOS:Core 9.0.0, RTOS:Coroutines 9.0.0, RTOS:Event Groups 9.0.0, RTOS:Heap 9.0.0, RTOS:Timers 9.0.0, CMSIS:CORE 5.0.1, Compiler:I/O:STDOUT 1.2.0
